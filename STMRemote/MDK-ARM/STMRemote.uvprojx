# Keil uVision project STMRemote.uvprojx, settings and files
target STMRemote (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F072R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F072
  c include: ..\inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_StdPeriph_Driver\inc;..\Drivers\STMTouch_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072.s
  group CMSIS
    ../src/: system_stm32f0xx.c
  group STM32F0xx_StdPeriph_Driver
    ../Drivers/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_spi.c stm32f0xx_exti.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_i2c.c
  group STMTouch_Driver
    ../Drivers/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32f0xx.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32f0xx.c tsl_touchkey.c
  group User
    ../src/: main.c tsl_user.c stm32f0xx_it.c
software components: CMSIS:CORE 4.1.0
